<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\v.8.00\device_2_v_8_2_11.ewp</path>
  </project>
  <batchBuild/>
</workspace>


